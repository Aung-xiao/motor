# Keil uVision project TIM.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Drive\inc;.\HARDWARE\CAN;.\HARDWARE\INCLUDE;.\HARDWARE\M3508;.\HARDWARE\PID;.\RTE\Device\STM32F103C8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group DRIVE
    ./Drive/src/: led.c delay.c key.c usart.c tim.c sys.c
  group HARDWARE
    ./HARDWARE/CAN/: can.c can.h
    ./HARDWARE/INCLUDE/: includes.h
    ./HARDWARE/LED/: led.h
    ./HARDWARE/M3508/: m3508.c m3508.h
    ./HARDWARE/PID/: pid.c pid.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
